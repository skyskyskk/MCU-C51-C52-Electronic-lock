# Keil uVision project Electronic_lock.uvproj, settings and files
target Electronic_lock (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: Electronic_lock +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\boards;..\utils
  group boards
    ./: STARTUP.A51
  group utils
    ../utils/: system_config.h
  group user
    ../user/: main.c
  group Doc
    ../Doc/: read.txt
